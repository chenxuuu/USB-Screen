# Keil uVision project bootloader.uvproj, settings and files
target HidDevice (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: bootloader +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Device;..\User\Host;..\User;..\User\PUB;..\User\PUB\INC
  group BootLoader
    ./: Main.c
