# Keil uVision project UsbScreen.uvproj, settings and files
target HidDevice (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: UsbScreen +hex
  c flags: Optimize=8 SizeSpeed=1
  group UsbScreen
    ./: Main.c
